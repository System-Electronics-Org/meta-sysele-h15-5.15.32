# Fix LICENSE format - CC0 1.0 Universal should be CC0-1.0
LICENSE = "CC0-1.0"