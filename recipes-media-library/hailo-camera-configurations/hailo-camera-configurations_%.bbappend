# Override SRC_URI to use erangur's dual-sensor branch
# This is required for dual-camera support on Astrial H15

SRC_URI = "git://git@github.com/erangur/hailo-camera-configurations.git;protocol=https;branch=master"
